# IAR project iar.ewp, settings and files
configuration  (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TARGET_K64F; TARGET_M4; TARGET_Freescale; __CORTEX_M4; ARM_MATH_CM4; __MBED__=1; CPU_MK64FN1M0VMD12; FSL_RTOS_MBED
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
