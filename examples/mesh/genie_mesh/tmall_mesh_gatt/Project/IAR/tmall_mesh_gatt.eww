<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\tmall_mesh_gatt.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>