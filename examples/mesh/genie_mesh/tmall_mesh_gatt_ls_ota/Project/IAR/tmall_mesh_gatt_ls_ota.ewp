# IAR project tmall_mesh_gatt_ls_ota.ewp, settings and files
configuration tmall_mesh_gatt_ls_ota (ARM, debug)
  General.OGChipSelectEditMenu: LE501X Linkedsemi LE501X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LE501X
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pe188,Pa089,Pe068,Pa039,Pa131,Pe111; --warnings_are_errors
  ICCARM.CCIncludePath2: ..\..\Include; ..\..; ..\..\..\genie_files; ..\..\..\..\..\..\module\tinycrypt\lib\include\tinycrypt; ..\..\..\..\..\..\hal_driver\inc; ..\..\..\..\..\..\hal_driver\api; ..\..\..\..\..\..\module\common; ..\..\..\..\..\..\module\crc; ..\..\..\..\..\..\module\debug; ..\..\..\..\..\..\module\debug\RTT; ..\..\..\..\..\..\module\static_buffer; ..\..\..\..\..\..\module\tinyfs; ..\..\..\..\..\..\module\tinycrypt\lib\include; ..\..\..\..\..\..\module\ble; ..\..\..\..\..\..\module\ble\prf; ..\..\..\..\..\..\module\settings; ..\..\..\..\..\..\soc; ..\..\..\..\..\..\soc\arm_cm; ..\..\..\..\..\..\soc\arm_cm\cmsis; ..\..\..\..\..\..\soc\arm_cm\le501x; ..\..\..\..\..\..\soc\arm_cm\le501x\integration
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tmall_mesh_gatt_ls_ota.hex
  postbuild: ..\..\..\..\..\..\tools\le501x\postbuild_iar.bat tmall_mesh_gatt_ls_ota ..\..\..\..\..\.. 403005440 $PROJ_DIR$ soc\arm_cm\le501x\bin\fw_with_sig_mesh.hex
  ILINK.IlinkOutputFile: tmall_mesh_gatt_ls_ota.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\soc\arm_cm\le501x\compiler\iar\mesh.ld
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009; --warnings_are_errors; --config_search ..\..\..\..\..\..\soc/arm_cm/le501x/compiler/iar
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group default
    ../../../../../../module/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dh.h ecc_dsa.h ecc_platform_specific.h hmac.h hmac_prng.h sha256.h utils.h
    ../../../genie_files/: ali_dfu_port.h genie_crc16.h genie_crypto.h genie_time_v2.h genie_triple.h slist.h tmall_genie_ais.h tmall_genie_ais_main_handle.h tmall_genie_log.h tmall_genie_ota.h tmall_genie_triple_handle.h
    ../../Include/: app_config.h tmall_ais_cfg.h tmall_curtain_cfg.h tmall_light_cfg.h tmall_mesh_ctl.h
    ../../../../../../soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../../../../module/common/: async_call.h circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.h linked_async_framework.h sw_timer.h sw_timer_int.h
    ../../../../../../module/ble/: ble_common_api.h builtin_timer.h ls_24g.h ls_ble.h ls_mesh.h ls_sig_mesh.h ls_sig_mesh_provisioner.h ls_sys.h rssi_smoothing_algo.h
    ../../../../../../soc/arm_cm/le501x/integration/: calc_acc.h dmac_config.h gpio_mode.h ls_msp_adc.h ls_msp_cache.h ls_msp_crypt.h ls_msp_dmac.h ls_msp_ecc.h ls_msp_i2c.h ls_msp_iwdg.h ls_msp_pdm.h ls_msp_pis.h ls_msp_qspi.h ls_msp_rtc.h ls_msp_spi_i2s.h ls_msp_ssi.h ls_msp_timer.h ls_msp_trng.h ls_msp_uart.h ls_msp_wwdg.h ls_soc_gpio.h ls_soc_pinmux.h modem_rf_le501x.h modem_rf_le501x_24g.h pis_config.h reg_base_addr.h reg_exti_type.h reg_gpio.h reg_gpio_type.h reg_lptim.h reg_mdm2.h reg_mdm2_type.h reg_rcc.h reg_rcc_type.h reg_rf.h reg_rf_type.h reg_syscfg.h reg_syscfg_type.h
    ../../../../../../hal_driver/api/: calc_div.h HAL_def.h ls_hal_adc.h ls_hal_adcv2.h ls_hal_cache.h ls_hal_can.h ls_hal_comp.h ls_hal_crc.h ls_hal_crypt.h ls_hal_dac.h ls_hal_dmac.h ls_hal_dmacv2.h ls_hal_ecc.h ls_hal_flash.h ls_hal_i2c.h ls_hal_iwdg.h ls_hal_iwdgv2.h ls_hal_patch.h ls_hal_pdm.h ls_hal_pis.h ls_hal_rtc.h ls_hal_rtcv2.h ls_hal_sha.h ls_hal_sm4.h ls_hal_spi_i2s.h ls_hal_ssi.h ls_hal_timer.h ls_hal_touchkey.h ls_hal_trng.h ls_hal_uart.h ls_hal_wwdg.h ls_ll_i2c.h ls_ll_opamp.h ls_ll_spi.h ls_ll_ssi.h ls_ll_timer.h ls_ll_uart.h
    ../../../../../../soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h systick.h
    ../../../../../../module/crc/: crc16.h
    ../../../../../../module/static_buffer/: fifo.h linked_buffer.h
    ../../../../../../hal_driver/inc/: hal_flash_int.h i2c_misc.h ls_hal_qspi.h ls_hal_qspiv2.h musb_type.h reg_adc_type.h reg_adcv2_type.h reg_cache_type.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_comp_type.h reg_crypt_type.h reg_dac_type.h reg_dmac_type.h reg_dmacv2_type.h reg_ecc_type.h reg_i2c_type.h reg_iwdg_type.h reg_iwdgv2_type.h reg_lcd_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_qspi_type.h reg_qspiv2_type.h reg_rtc_type.h reg_rtcv2_type.h reg_sha_type.h reg_sm4_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_touchkey_type.h reg_trng_type.h reg_trngv2_type.h reg_uart_type.h reg_usb_type.h reg_wwdg_type.h ssi_misc.h
    ../../../../../../module/settings/: inflash_settings.h ota_settings.h
    ../../../../../../soc/arm_cm/: instructions.h swint_call_asm.h
    ../../../../../../soc/arm_cm/le501x/: le501x.h lssoftiic.h lstk.h platform.h portmacro.h sdk_default_config.h sleep.h sw_timer_port.h sys_stat.h tk_misc.h
    ../../../../../../module/debug/: log.h ls_dbg.h
    ../../../../../../module/ble/prf/: prf_ancs.h prf_bass.h prf_diss.h prf_fotas.h prf_hid.h
    ../../../../../../module/debug/RTT/: SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../../../../../module/tinyfs/: tinyfs.h tinyfs_config.h tinyfs_nvm.h tinyfs_write_cache.h
  group examples
    ../../../genie_files/: ali_dfu_port.c genie_crc16.c genie_crypto.c genie_time_v2.c genie_triple.c tmall_genie_ais.c tmall_genie_ais_main_handle.c tmall_genie_ota.c tmall_genie_triple_handle.c
    ../../Source/: main.c tmall_light_cfg.c tmall_mesh_ctl.c
  group hal_driver
    ../../../../../../hal_driver/src/: calc_div.c ls_hal_adc.c ls_hal_adc_dma.c ls_hal_cache.c ls_hal_crypt.c ls_hal_dmac.c ls_hal_ecc.c ls_hal_flash.c ls_hal_flash_qspi.c ls_hal_flash_swint.c ls_hal_i2c.c ls_hal_i2c_dma.c ls_hal_iwdg.c ls_hal_pdm.c ls_hal_pdm_dma.c ls_hal_pis.c ls_hal_qspi.c ls_hal_rtc.c ls_hal_spi_i2s.c ls_hal_spi_i2s_dma.c ls_hal_ssi.c ls_hal_ssi_dma.c ls_hal_timer.c ls_hal_trng.c ls_hal_uart.c ls_hal_uart_dma.c ls_hal_wwdg.c
  group libs
    ../../../../../../soc/arm_cm/le501x/bin/: libmesh.o
  group module
    ../../../../../../module/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c sha256.c utils.c
    ../../../../../../module/ble/: ble_common_api.c
    ../../../../../../module/common/: circular_doubly_linked_list.c common.c sw_timer.c
    ../../../../../../module/crc/: crc16.c
    ../../../../../../module/static_buffer/: fifo.c linked_buffer.c
    ../../../../../../module/settings/: inflash_settings.c ota_settings.c
    ../../../../../../module/debug/: log.c ls_dbg.c
    ../../../../../../module/debug/RTT/: SEGGER_RTT.c
    ../../../../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
  group soc
    ../../../../../../soc/arm_cm/le501x/integration/: calc_acc.c ls_msp_adc.c ls_msp_cache.c ls_msp_crypt.c ls_msp_dmac.c ls_msp_ecc.c ls_msp_i2c.c ls_msp_iwdg.c ls_msp_pdm.c ls_msp_pis.c ls_msp_qspi.c ls_msp_rtc.c ls_msp_spi_i2s.c ls_msp_ssi.c ls_msp_timer.c ls_msp_trng.c ls_msp_uart.c ls_msp_wwdg.c ls_soc_gpio.c modem_rf_le501x.c modem_rf_le501x_24g.c
    ../../../../../../soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sw_timer_port.c sys_stat.c
    ../../../../../../soc/arm_cm/le501x/compiler/iar/: delay_asm.S sleep_asm.S stack_asm.S startup.S swint_asm.S
    ../../../../../../soc/arm_cm/: systick.c
