<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\sig_mesh_provisioner.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>