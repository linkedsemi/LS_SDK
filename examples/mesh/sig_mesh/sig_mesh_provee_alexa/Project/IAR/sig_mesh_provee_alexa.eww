<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\sig_mesh_provee_alexa.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>