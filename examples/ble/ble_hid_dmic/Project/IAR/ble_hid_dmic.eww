<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\ble_hid_dmic.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>