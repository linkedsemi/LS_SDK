# Keil uVision project fota.uvprojx, settings and files
target fota (ARM-ADS)
  device: LE501X Linkedsemi
  pack: Linkedsemi.DFP.1.0.0
  cpu: IROM(0x18000000,0x00080000) IRAM(0x20000000,0x00001000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: fota +hex
  AfterMake: ..\..\..\..\..\tools\le501x\after_build.bat @L ..\..\..\..\.. 402866176 soc\arm_cm\le501x\bin\fw.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: LE501X
  c misc: --diag_suppress=1,61,68,188,1295
  c include: ..\..\Include; ..\..; ..\..\..\..\..\hal_driver\inc; ..\..\..\..\..\hal_driver\api; ..\..\..\..\..\module\common; ..\..\..\..\..\module\crc; ..\..\..\..\..\module\debug; ..\..\..\..\..\module\debug\RTT; ..\..\..\..\..\module\static_buffer; ..\..\..\..\..\module\tinyfs; ..\..\..\..\..\module\tinycrypt\lib\include; ..\..\..\..\..\module\ble; ..\..\..\..\..\module\ble\prf; ..\..\..\..\..\module\settings; ..\..\..\..\..\soc; ..\..\..\..\..\soc\arm_cm; ..\..\..\..\..\soc\arm_cm\cmsis; ..\..\..\..\..\soc\arm_cm\le501x; ..\..\..\..\..\soc\arm_cm\le501x\integration
  asm misc: --cpreproc --cpreproc_opts=-DLE501X --diag_suppress=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\compiler\armcc\single_bank_fota_link.txt
  link misc: --datacompressor=off --diag_suppress=L6314,L6329
  group examples
    ../../Source/: main.c pub_key.c
  group hal_driver
    ../../../../../hal_driver/src/: calc_div.c ls_hal_adc.c ls_hal_adc_dma.c ls_hal_cache.c ls_hal_crypt.c ls_hal_dmac.c ls_hal_ecc.c ls_hal_flash.c ls_hal_flash_qspi.c ls_hal_flash_svcall.c ls_hal_i2c.c ls_hal_i2c_dma.c ls_hal_iwdg.c ls_hal_pdm.c ls_hal_pdm_dma.c ls_hal_pis.c ls_hal_qspi.c ls_hal_rtc.c ls_hal_spi_i2s.c ls_hal_spi_i2s_dma.c ls_hal_ssi.c ls_hal_ssi_dma.c ls_hal_timer.c ls_hal_trng.c ls_hal_uart.c ls_hal_uart_dma.c ls_hal_wwdg.c
  group libs
    ../../../../../soc/arm_cm/le501x/bin/: libfw.o
  group module
    ../../../../../module/ble/: ble_common_api.c
    ../../../../../module/common/: circular_doubly_linked_list.c common.c sw_timer.c
    ../../../../../module/crc/: crc16.c
    ../../../../../module/static_buffer/: fifo.c linked_buffer.c
    ../../../../../module/settings/: inflash_settings.c ota_settings.c
    ../../../../../module/debug/: log.c ls_dbg.c
    ../../../../../module/debug/RTT/: SEGGER_RTT.c
    ../../../../../module/tinycrypt/lib/source/: sha256.c utils.c
    ../../../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
  group soc
    ../../../../../soc/arm_cm/le501x/integration/: calc_acc.c ls_msp_adc.c ls_msp_cache.c ls_msp_crypt.c ls_msp_dmac.c ls_msp_ecc.c ls_msp_i2c.c ls_msp_iwdg.c ls_msp_pdm.c ls_msp_pis.c ls_msp_qspi.c ls_msp_rtc.c ls_msp_spi_i2s.c ls_msp_ssi.c ls_msp_timer.c ls_msp_trng.c ls_msp_uart.c ls_msp_wwdg.c ls_soc_gpio.c modem_rf_le501x.c modem_rf_le501x_24g.c
    ../../../../../soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sw_timer_port.c sys_stat.c
    ../../../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S sleep_asm.S stack_asm.S startup.S svcall_asm.S
    ../../../../../soc/arm_cm/: svcall.c swint_handler.c systick.c
target info_sbl.hex (ARM-ADS)
  device: ARMCM0 ARM
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: info_sbl.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target fw.hex (ARM-ADS)
  device: ARMCM0 ARM
  cpu: as above
  output: fw.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
