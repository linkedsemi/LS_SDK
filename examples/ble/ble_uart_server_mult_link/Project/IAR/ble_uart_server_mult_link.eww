<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\ble_uart_server_mult_link.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>