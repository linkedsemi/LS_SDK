<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\ble_mult_services.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>