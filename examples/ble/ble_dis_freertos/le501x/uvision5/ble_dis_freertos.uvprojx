# Keil uVision project ble_dis_freertos.uvprojx, settings and files
target ble_dis_freertos (ARM-ADS)
  device: ARMCM0 ARM
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_dis_freertos
  AfterMake: ..\..\..\..\..\tools\le501x\after_build.bat @L ..\..\..\..\.. 402866176 soc\arm_cm\le501x\bin\fw.hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: LE501X
  c include: ..\..; ..\..\..\..\..\peripheral\inc; ..\..\..\..\..\peripheral\api; ..\..\..\..\..\module\common; ..\..\..\..\..\module\crc; ..\..\..\..\..\module\debug; ..\..\..\..\..\module\debug\RTT; ..\..\..\..\..\module\static_buffer; ..\..\..\..\..\module\tinyfs; ..\..\..\..\..\module\tinycrypt\lib\include; ..\..\..\..\..\module\ble; ..\..\..\..\..\module\ble\prf; ..\..\..\..\..\module\settings; ..\..\..\..\..\soc; ..\..\..\..\..\soc\arm_cm; ..\..\..\..\..\soc\arm_cm\cmsis; ..\..\..\..\..\soc\arm_cm\le501x; ..\..\..\..\..\soc\arm_cm\le501x\integration; ..\..\..\..\..\rtos\freertos\include
  asm misc: --cpreproc --cpreproc_opts=-DLE501X
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\..\..\..\soc\arm_cm\le501x\compiler\armcc\ble.ld
  link misc: --datacompressor=off --diag_suppress=L6314,L6329
  group default
    ../../../../../peripheral/inc/: adc_msp.h crc_msp.h dmac_msp.h flash_svcall.h i2c_misc.h i2c_msp.h lscache_msp.h lscrypt_msp.h lsecc_msp.h lsiwdg_msp.h lspdm_msp.h lspis_msp.h lsqspi.h lsqspi_msp.h lsqspiv2.h lsqspiv2_msp.h lstimer_msp.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_dmac_type.h reg_i2c_type.h reg_lcd_type.h reg_lsadc_type.h reg_lscache_type.h reg_lscrypt_type.h reg_lsecc_type.h reg_lsiwdg_type.h reg_lsqspi_type.h reg_lsqspiv2_type.h reg_lstrng_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_rtc_type.h reg_sha_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_uart_type.h reg_usb_type.h rtc_msp.h sha_msp.h spi_flash_int.h spi_msp.h ssi_misc.h ssi_msp.h trng_msp.h uart_misc.h uart_msp.h
    ../../: app_config.h FreeRTOSConfig.h
    ../../../../../soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../../../module/common/: async_call.h circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.h linked_async_framework.h sw_timer.h sw_timer_port.h
    ../../../../../rtos/freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../../../../../module/ble/: ble_common_api.h builtin_timer.h ls_24g.h ls_ble.h ls_mesh.h ls_sig_mesh.h ls_sig_mesh_provisioner.h ls_sys.h rssi_smoothing_algo.h
    ../../../../../soc/arm_cm/le501x/integration/: calc_acc.h dmac_config.h gpio_mode.h io_config.h modem_rf_le501x.h modem_rf_le501x_24g.h pis_config.h reg_base_addr.h reg_lptim.h reg_lsexti_type.h reg_lsgpio.h reg_lsgpio_type.h reg_mdm2.h reg_mdm2_type.h reg_rcc.h reg_rcc_type.h reg_rf.h reg_rf_type.h reg_syscfg.h reg_syscfg_type.h
    ../../../../../peripheral/api/: calc_div.h HAL_def.h lsadc.h lscache.h lscrc.h lscrypt.h lsdmac.h lsecc.h lsi2c.h lsiwdg.h lspatch.h lspdm.h lspis.h lsrtc.h lssha.h lsspi.h lsssi.h lstimer.h lstrng.h lsuart.h spi_flash.h
    ../../../../../soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h sdk_default_config.h systick.h
    ../../../../../module/crc/: crc16.h
    ../../../../../module/static_buffer/: fifo.h linked_buffer.h
    ../../../../../soc/arm_cm/le501x/: flash_svcall_int.h le501x.h lssoftiic.h lstk.h platform.h portmacro.h sleep.h sys_stat.h tk_misc.h
    ../../../../../module/settings/: inflash_settings.h ota_settings.h
    ../../../../../soc/arm_cm/: instructions.h svcall.h swint_call_asm.h
    ../../../../../module/debug/: log.h ls_dbg.h
    ../../../../../module/ble/prf/: prf_ancs.h prf_bass.h prf_diss.h prf_fotas.h prf_hid.h
    ../../../../../module/debug/RTT/: SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../../../../module/tinyfs/: tinyfs.h tinyfs_config.h tinyfs_nvm.h tinyfs_write_cache.h
  group examples
    ../../: main.c
  group libs
    ../../../../../soc/arm_cm/le501x/bin/: libfw.o
  group module
    ../../../../../module/ble/: ble_common_api.c
    ../../../../../module/common/: circular_doubly_linked_list.c common.c sw_timer.c
    ../../../../../module/crc/: crc16.c
    ../../../../../module/static_buffer/: fifo.c linked_buffer.c
    ../../../../../module/settings/: inflash_settings.c ota_settings.c
    ../../../../../module/debug/: log.c ls_dbg.c
    ../../../../../module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../../../module/debug/RTT/: SEGGER_RTT.c
    ../../../../../module/tinycrypt/lib/source/: sha256.c utils.c
    ../../../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
  group peripheral
    ../../../../../peripheral/src/: adc_dma.c calc_div.c dmac.c flash_svcall.c lsadc.c lscache.c lscrypt.c lsecc.c lsi2c.c lsiwdg.c lspdm.c lspdm_dma.c lspis.c lsqspi.c lsrtc.c lsspi.c lsspi_dma.c lsssi.c lsssi_dma.c lstimer.c lstrng.c spi_flash.c spi_flash_lsqspi.c uart.c uart_dma.c
  group rtos
    ../../../../../rtos/freertos/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
  group soc
    ../../../../../soc/arm_cm/le501x/integration/: adc_msp.c calc_acc.c dmac_msp.c i2c_msp.c io_config.c lscache_msp.c lscrypt_msp.c lsecc_msp.c lsiwdg_msp.c lspdm_msp.c lspis_msp.c lsqspi_msp.c lstimer_msp.c modem_rf_le501x.c modem_rf_le501x_24g.c rtc_msp.c spi_msp.c ssi_msp.c trng_msp.c uart_msp.c
    ../../../../../soc/arm_cm/le501x/: cpu.c freertos_adapt_ble.c platform.c sleep.c stack_var.c sw_timer_port.c sys_stat.c
    ../../../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S port.c sleep_asm.S startup.S svcall_asm.S
    ../../../../../soc/arm_cm/: svcall.c swint_handler.c systick.c
target info_sbl.hex (ARM-ADS)
  device: ARMCM0 ARM
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: info_sbl.hex
  group left out of the first target's files
    ../../../../../module/ble/: ble_common_api.c ble_common_api.h builtin_timer.h ls_24g.h ls_ble.h ls_mesh.h ls_sig_mesh.h ls_sig_mesh_provisioner.h ls_sys.h rssi_smoothing_algo.h
    ../../../../../module/ble/prf/: prf_ancs.h prf_bass.h prf_diss.h prf_fotas.h prf_hid.h
    ../../../../../module/common/: async_call.h circular_doubly_linked_list.c circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.c common.h linked_async_framework.h sw_timer.c sw_timer.h sw_timer_port.h
    ../../../../../module/crc/: crc16.c crc16.h
    ../../../../../module/debug/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../../../../module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../../../module/debug/: log.c log.h ls_dbg.c ls_dbg.h
    ../../../../../module/settings/: inflash_settings.c inflash_settings.h ota_settings.c ota_settings.h
    ../../../../../module/static_buffer/: fifo.c fifo.h linked_buffer.c linked_buffer.h
    ../../../../../module/tinycrypt/lib/source/: sha256.c utils.c
    ../../../../../module/tinyfs/: tinyfs.c tinyfs.h tinyfs_config.h tinyfs_nvm.c tinyfs_nvm.h tinyfs_write_cache.c tinyfs_write_cache.h
    ../../../../../peripheral/api/: HAL_def.h calc_div.h lsadc.h lscache.h lscrc.h lscrypt.h lsdmac.h lsecc.h lsi2c.h lsiwdg.h lspatch.h lspdm.h lspis.h lsrtc.h lssha.h lsspi.h lsssi.h lstimer.h lstrng.h lsuart.h spi_flash.h
    ../../../../../peripheral/inc/: adc_msp.h crc_msp.h dmac_msp.h flash_svcall.h i2c_misc.h i2c_msp.h lscache_msp.h lscrypt_msp.h lsecc_msp.h lsiwdg_msp.h lspdm_msp.h lspis_msp.h lsqspi.h lsqspi_msp.h lsqspiv2.h lsqspiv2_msp.h lstimer_msp.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_dmac_type.h reg_i2c_type.h reg_lcd_type.h reg_lsadc_type.h reg_lscache_type.h reg_lscrypt_type.h reg_lsecc_type.h reg_lsiwdg_type.h reg_lsqspi_type.h reg_lsqspiv2_type.h reg_lstrng_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_rtc_type.h reg_sha_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_uart_type.h reg_usb_type.h rtc_msp.h sha_msp.h spi_flash_int.h spi_msp.h ssi_misc.h ssi_msp.h trng_msp.h uart_misc.h uart_msp.h
    ../../../../../peripheral/src/: adc_dma.c calc_div.c dmac.c flash_svcall.c lsadc.c lscache.c lscrypt.c lsecc.c lsi2c.c lsiwdg.c lspdm.c lspdm_dma.c lspis.c lsqspi.c lsrtc.c lsspi.c lsspi_dma.c lsssi.c lsssi_dma.c lstimer.c lstrng.c spi_flash.c spi_flash_lsqspi.c uart.c uart_dma.c
    ../../../../../rtos/freertos/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../rtos/freertos/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../../../../../soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../../../soc/arm_cm/: instructions.h svcall.c svcall.h swint_call_asm.h swint_handler.c systick.c
    ../../../../../soc/arm_cm/le501x/bin/: libfw.o
    ../../../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S port.c sleep_asm.S startup.S svcall_asm.S
    ../../../../../soc/arm_cm/le501x/: cpu.c flash_svcall_int.h freertos_adapt_ble.c le501x.h lssoftiic.h lstk.h platform.c platform.h portmacro.h sleep.c sleep.h stack_var.c sw_timer_port.c sys_stat.c sys_stat.h tk_misc.h
    ../../../../../soc/arm_cm/le501x/integration/: adc_msp.c calc_acc.c calc_acc.h dmac_config.h dmac_msp.c gpio_mode.h i2c_msp.c io_config.c io_config.h lscache_msp.c lscrypt_msp.c lsecc_msp.c lsiwdg_msp.c lspdm_msp.c lspis_msp.c lsqspi_msp.c lstimer_msp.c modem_rf_le501x.c modem_rf_le501x.h modem_rf_le501x_24g.c modem_rf_le501x_24g.h pis_config.h reg_base_addr.h reg_lptim.h reg_lsexti_type.h reg_lsgpio.h reg_lsgpio_type.h reg_mdm2.h reg_mdm2_type.h reg_rcc.h reg_rcc_type.h reg_rf.h reg_rf_type.h reg_syscfg.h reg_syscfg_type.h rtc_msp.c spi_msp.c ssi_msp.c trng_msp.c uart_msp.c
    ../../../../../soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h sdk_default_config.h systick.h
    ../../: FreeRTOSConfig.h app_config.h main.c
target fw.hex (ARM-ADS)
  device: ARMCM0 ARM
  cpu: as above
  output: fw.hex
  group left out of the first target's files
    ../../../../../module/ble/: ble_common_api.c ble_common_api.h builtin_timer.h ls_24g.h ls_ble.h ls_mesh.h ls_sig_mesh.h ls_sig_mesh_provisioner.h ls_sys.h rssi_smoothing_algo.h
    ../../../../../module/ble/prf/: prf_ancs.h prf_bass.h prf_diss.h prf_fotas.h prf_hid.h
    ../../../../../module/common/: async_call.h circular_doubly_linked_list.c circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.c common.h linked_async_framework.h sw_timer.c sw_timer.h sw_timer_port.h
    ../../../../../module/crc/: crc16.c crc16.h
    ../../../../../module/debug/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../../../../module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../../../module/debug/: log.c log.h ls_dbg.c ls_dbg.h
    ../../../../../module/settings/: inflash_settings.c inflash_settings.h ota_settings.c ota_settings.h
    ../../../../../module/static_buffer/: fifo.c fifo.h linked_buffer.c linked_buffer.h
    ../../../../../module/tinycrypt/lib/source/: sha256.c utils.c
    ../../../../../module/tinyfs/: tinyfs.c tinyfs.h tinyfs_config.h tinyfs_nvm.c tinyfs_nvm.h tinyfs_write_cache.c tinyfs_write_cache.h
    ../../../../../peripheral/api/: HAL_def.h calc_div.h lsadc.h lscache.h lscrc.h lscrypt.h lsdmac.h lsecc.h lsi2c.h lsiwdg.h lspatch.h lspdm.h lspis.h lsrtc.h lssha.h lsspi.h lsssi.h lstimer.h lstrng.h lsuart.h spi_flash.h
    ../../../../../peripheral/inc/: adc_msp.h crc_msp.h dmac_msp.h flash_svcall.h i2c_misc.h i2c_msp.h lscache_msp.h lscrypt_msp.h lsecc_msp.h lsiwdg_msp.h lspdm_msp.h lspis_msp.h lsqspi.h lsqspi_msp.h lsqspiv2.h lsqspiv2_msp.h lstimer_msp.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_dmac_type.h reg_i2c_type.h reg_lcd_type.h reg_lsadc_type.h reg_lscache_type.h reg_lscrypt_type.h reg_lsecc_type.h reg_lsiwdg_type.h reg_lsqspi_type.h reg_lsqspiv2_type.h reg_lstrng_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_rtc_type.h reg_sha_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_uart_type.h reg_usb_type.h rtc_msp.h sha_msp.h spi_flash_int.h spi_msp.h ssi_misc.h ssi_msp.h trng_msp.h uart_misc.h uart_msp.h
    ../../../../../peripheral/src/: adc_dma.c calc_div.c dmac.c flash_svcall.c lsadc.c lscache.c lscrypt.c lsecc.c lsi2c.c lsiwdg.c lspdm.c lspdm_dma.c lspis.c lsqspi.c lsrtc.c lsspi.c lsspi_dma.c lsssi.c lsssi_dma.c lstimer.c lstrng.c spi_flash.c spi_flash_lsqspi.c uart.c uart_dma.c
    ../../../../../rtos/freertos/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../rtos/freertos/include/: FreeRTOS.h StackMacros.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ../../../../../soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../../../soc/arm_cm/: instructions.h svcall.c svcall.h swint_call_asm.h swint_handler.c systick.c
    ../../../../../soc/arm_cm/le501x/bin/: libfw.o
    ../../../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S port.c sleep_asm.S startup.S svcall_asm.S
    ../../../../../soc/arm_cm/le501x/: cpu.c flash_svcall_int.h freertos_adapt_ble.c le501x.h lssoftiic.h lstk.h platform.c platform.h portmacro.h sleep.c sleep.h stack_var.c sw_timer_port.c sys_stat.c sys_stat.h tk_misc.h
    ../../../../../soc/arm_cm/le501x/integration/: adc_msp.c calc_acc.c calc_acc.h dmac_config.h dmac_msp.c gpio_mode.h i2c_msp.c io_config.c io_config.h lscache_msp.c lscrypt_msp.c lsecc_msp.c lsiwdg_msp.c lspdm_msp.c lspis_msp.c lsqspi_msp.c lstimer_msp.c modem_rf_le501x.c modem_rf_le501x.h modem_rf_le501x_24g.c modem_rf_le501x_24g.h pis_config.h reg_base_addr.h reg_lptim.h reg_lsexti_type.h reg_lsgpio.h reg_lsgpio_type.h reg_mdm2.h reg_mdm2_type.h reg_rcc.h reg_rcc_type.h reg_rf.h reg_rf_type.h reg_syscfg.h reg_syscfg_type.h rtc_msp.c spi_msp.c ssi_msp.c trng_msp.c uart_msp.c
    ../../../../../soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h sdk_default_config.h systick.h
    ../../: FreeRTOSConfig.h app_config.h main.c
