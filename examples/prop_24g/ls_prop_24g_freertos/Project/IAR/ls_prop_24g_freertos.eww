<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\ls_prop_24g_freertos.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>