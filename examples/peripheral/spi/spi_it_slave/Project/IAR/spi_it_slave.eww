<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\spi_it_slave.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>