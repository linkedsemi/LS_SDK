# IAR project iap_bootloader.ewp, settings and files
configuration iap_bootloader (ARM, debug)
  General.OGChipSelectEditMenu: Default None Default
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LM3050
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pe188,Pa089,Pe068,Pa039,Pa131,Pe111; --warnings_are_errors
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\hal_driver\inc; ..\..\..\..\..\..\hal_driver\api; ..\..\..\..\..\..\module\common; ..\..\..\..\..\..\module\debug; ..\..\..\..\..\..\module\debug\RTT; ..\..\..\..\..\..\soc; ..\..\..\..\..\..\soc\arm_cm; ..\..\..\..\..\..\soc\arm_cm\cmsis; ..\..\..\..\..\..\soc\arm_cm\lm3050
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: name.srec
  prebuild: ..\..\..\..\..\..\tools\lm3050\prebuild_iar.bat ..\..\..\..\..\.. $PROJ_DIR$
  ILINK.IlinkOutputFile: iap_bootloader.out
  ILINK.IlinkIcfFile: ..\..\compiler\iar\lm3050_mcu_link.txt
  ILINK.IlinkExtraOptions: --diag_suppress=Lt009; --warnings_are_errors; --config_search ..\..\..\..\..\..\soc/arm_cm/lm3050/compiler/iar
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group default
    ../../: app_config.h iap_sha256.h uart_process.h upgrade_process.h
    ../../../../../../soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../../../../module/common/: async_call.h circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.h linked_async_framework.h sw_timer.h sw_timer_int.h
    ../../../../../../hal_driver/api/: calc_div.h HAL_def.h ls_hal_adc.h ls_hal_adcv2.h ls_hal_cache.h ls_hal_can.h ls_hal_comp.h ls_hal_crc.h ls_hal_crypt.h ls_hal_dac.h ls_hal_dmac.h ls_hal_dmacv2.h ls_hal_ecc.h ls_hal_flash.h ls_hal_i2c.h ls_hal_iwdg.h ls_hal_iwdgv2.h ls_hal_patch.h ls_hal_pdm.h ls_hal_pis.h ls_hal_rtc.h ls_hal_rtcv2.h ls_hal_sha.h ls_hal_sm4.h ls_hal_spi_i2s.h ls_hal_ssi.h ls_hal_timer.h ls_hal_touchkey.h ls_hal_trng.h ls_hal_uart.h ls_hal_wwdg.h ls_ll_i2c.h ls_ll_opamp.h ls_ll_spi.h ls_ll_ssi.h ls_ll_timer.h ls_ll_uart.h
    ../../../../../../soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h systick.h
    ../../../../../../soc/arm_cm/lm3050/: dmac_config.h lm3050.h ls_msp_adc.h ls_msp_cache.h ls_msp_can.h ls_msp_comp.h ls_msp_crc.h ls_msp_crypt.h ls_msp_dac.h ls_msp_dmacv2.h ls_msp_ecc.h ls_msp_i2c.h ls_msp_iwdg.h ls_msp_pdm.h ls_msp_pis.h ls_msp_qspiv2.h ls_msp_rtc.h ls_msp_sha.h ls_msp_sm4.h ls_msp_spi_i2s.h ls_msp_ssi.h ls_msp_timer.h ls_msp_touchkey.h ls_msp_trngv2.h ls_msp_uart.h ls_msp_usb.h ls_msp_wwdg.h ls_soc_gpio.h ls_soc_pinmux.h per_func_mux.h pis_config.h platform.h portmacro.h qspiv2_config.h reg_base_addr.h reg_exti_type.h reg_lstim_type.h reg_sysc_awo_type.h reg_sysc_cpu_type.h reg_sysc_per_type.h reg_v33_rg_type.h sdk_default_config.h sleep.h sw_timer_port.h sys_stat.h
    ../../../../../../hal_driver/inc/: hal_flash_int.h i2c_misc.h ls_hal_qspi.h ls_hal_qspiv2.h musb_type.h reg_adc_type.h reg_adcv2_type.h reg_cache_type.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_comp_type.h reg_crypt_type.h reg_dac_type.h reg_dmac_type.h reg_dmacv2_type.h reg_ecc_type.h reg_i2c_type.h reg_iwdg_type.h reg_iwdgv2_type.h reg_lcd_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_qspi_type.h reg_qspiv2_type.h reg_rtc_type.h reg_rtcv2_type.h reg_sha_type.h reg_sm4_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_touchkey_type.h reg_trng_type.h reg_trngv2_type.h reg_uart_type.h reg_usb_type.h reg_wwdg_type.h ssi_misc.h
    ../../../../../../soc/arm_cm/: instructions.h swint_call_asm.h
    ../../../../../../module/debug/: log.h ls_dbg.h
    ../../../../../../module/debug/RTT/: SEGGER_RTT.h SEGGER_RTT_Conf.h
  group examples
    ../../: iap_sha256.c main.c uart_process.c upgrade_process.c
  group hal_driver
    ../../../../../../hal_driver/src/: ls_hal_adcv2.c ls_hal_adcv2_dma.c ls_hal_cache.c ls_hal_can.c ls_hal_comp.c ls_hal_crc.c ls_hal_crypt.c ls_hal_dac.c ls_hal_dac_dma.c ls_hal_dmacv2.c ls_hal_ecc.c ls_hal_flash.c ls_hal_flash_qspiv2.c ls_hal_flash_swint.c ls_hal_i2c.c ls_hal_i2c_dma.c ls_hal_iwdgv2.c ls_hal_pdm.c ls_hal_pis.c ls_hal_qspiv2.c ls_hal_rtcv2.c ls_hal_sha.c ls_hal_sm4.c ls_hal_spi_i2s.c ls_hal_spi_i2s_dma.c ls_hal_ssi.c ls_hal_ssi_dma.c ls_hal_timer.c ls_hal_touchkey.c ls_hal_trngv2.c ls_hal_uart.c ls_hal_uart_dma.c ls_hal_wwdg.c
  group module
    ../../../../../../module/common/: circular_doubly_linked_list.c common.c sw_timer.c
    ../../../../../../module/debug/: log.c ls_dbg.c
    ../../../../../../module/debug/RTT/: SEGGER_RTT.c
  group soc
    ../../../../../../soc/arm_cm/lm3050/: __info_array.c cpu.c ls_msp_adc.c ls_msp_cache.c ls_msp_can.c ls_msp_comp.c ls_msp_crc.c ls_msp_crypt.c ls_msp_dac.c ls_msp_dmacv2.c ls_msp_ecc.c ls_msp_i2c.c ls_msp_iwdg.c ls_msp_pdm.c ls_msp_pis.c ls_msp_qspiv2.c ls_msp_rtc.c ls_msp_sha.c ls_msp_sm4.c ls_msp_spi_i2s.c ls_msp_ssi.c ls_msp_timer.c ls_msp_touchkey.c ls_msp_trngv2.c ls_msp_uart.c ls_msp_wwdg.c ls_soc_gpio.c platform.c rom_flash_api_wrapper.c sleep.c sw_timer_port.c sys_stat.c
    ../../../../../../soc/arm_cm/lm3050/compiler/iar/: delay_asm.S sleep_asm.S startup.c startup_asm.S swint_asm.S
    ../../../../../../soc/arm_cm/: systick.c
