<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\Basic_TIM.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>