<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\pdm_pingpong_dma.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>