<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\des_ecb_cbc_it.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>