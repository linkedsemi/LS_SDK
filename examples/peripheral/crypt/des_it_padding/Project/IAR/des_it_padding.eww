<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\des_it_padding.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>