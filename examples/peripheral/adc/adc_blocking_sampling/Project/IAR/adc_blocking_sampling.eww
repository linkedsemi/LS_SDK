<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\adc_blocking_sampling.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>