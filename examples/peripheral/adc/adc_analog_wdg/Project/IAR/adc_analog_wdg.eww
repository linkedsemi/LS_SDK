<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\adc_analog_wdg.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>