<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\adc_amic_sampling.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>