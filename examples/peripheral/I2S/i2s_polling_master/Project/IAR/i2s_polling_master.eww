<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\i2s_polling_master.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>